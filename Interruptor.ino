#include <ESP8266WiFi.h>
#include <WiFiClient.h>
#include <ESP8266WebServer.h>
#include <FS.h>
#include <WebSocketsServer.h>
#define D1 5

//onde se insere as informações da rede (lembrar de usar um ip não utilizado pela rede)
IPAddress local_IP(192, 168, 15,236);
IPAddress gateway(192, 168, 15, 1);
IPAddress subnet(255, 255, 255, 0);

// inserir aqui suas credenciais da rede wifi
const char *ssid = "VIVOFIBRA-0058";
const char *password = "A21E614443";
WebSocketsServer webSocket = WebSocketsServer(81);
ESP8266WebServer server(80);


//local onde é gerado o arquivo html para ser enviado ao client
const char PaginaHTML[] PROGMEM = R"=====(



<!DOCTYPE html>
<html lang="en">
<script>
var connection = new WebSocket('ws://'+location.hostname+':81/');
function button_1_on()
{
  console.log("ON");
  connection.send("ON");
}
function button_1_off()
{
console.log("OFF");
connection.send("OFF");
}
</script>

<head>
    <meta charset="UTF-8">
    <meta http-equiv="X-UA-Compatible" content="IE=edge">
    <meta name="viewport" content="width=device-width, initial-scale=1.0">
    <title>Av2 - Sistemas Embarcados</title>
    <script src="https://cdn.tailwindcss.com"></script>
    <script defer src="https://unpkg.com/alpinejs@3.x.x/dist/cdn.min.js"></script>
</head>
<body
    x-init
    x-data="{clicou: 0, on: false}"
    class="grid min-h-screen w-full grid-cols-1 place-items-center justify-items-center bg-gradient-to-b"
    x-bind:class="on ? 'from-amber-400 to-amber-500' : 'from-slate-600 to-slate-900'"
  >
    <div
      class="container h-28 w-10/12 sm:w-1/2 lg:w-1/3"
      x-bind:class="on ? 'text-black' : 'text-white'"
    >
      <h1 class="text-center text-2xl font-bold">Av2 - Sistemas Embarcados</h1>
      <div
        class="my-2 h-1 w-full rounded"
        x-bind:class="on ? 'bg-black' : 'bg-white'"
      ></div>
      <p
        class="font-medium"
        x-html="!clicou ? 'Bem-vindo! Nosso projeto consiste em um interruptor para ligar e desligar uma lâmpada! Genial né? Ninguém nunca deve ter pensado em fazer isso antes! ¯/(ツ)/¯'
        : clicou === 1 ? 'Uau! Você acendeu a lâmpada!<br/> Parabéns, merece um prêmio nobel!<br/> (ﾉ◕ヮ◕)ﾉ*:･ﾟ✧'
        : clicou > 1 ? 'Pronto, é só isso que o programa faz mesmo.<br/>Pode ir embora ou continuar brincando com a lâmpada...<br/>¯/( ͡° ͜ʖ ͡°)/¯' : null"
      ></p>
    </div>
    <section
      class="container grid h-96 w-10/12 -translate-y-10 place-items-center justify-items-center rounded-md bg-gradient-to-br from-white to-slate-200 shadow-lg sm:w-1/2 lg:w-1/3"
    >
      <img
        x-bind:src="!on ? 'data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAgAAAAIACAYAAAD0eNT6AAAAAXNSR0IArs4c6QAAAARnQU1BAACxjwv8YQUAAAAJcEhZcwAADsMAAA7DAcdvqGQAABLsSURBVHhe7d3fr2bVXcfxfRjml8M5ME1BoFoJaZBGikR0YtRWLtFUKzdyoRcTb5o29l9oYqqS+iPGH7FqMRhN9cILa6KhjYmFmtqCaYUCChUahAnOTBnGMjMMP4Y5rjV7H3jmmf08ewbmjMz6vF7J171yuGASpp73WWvt53QAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAMRYGZ6wWe4oc1e/BM7RzWVe7ZdwfgkANtveMvf0S+Ac7Szzcr+E8+uS4QkABBEAABBIAABAIAEAAIEEAAAEEgAAEMhrgGy2qdcAj5T5ZL+EKDeW+Wi/XMhrgMBFqwbA+pLZXwYS3V5m7H8Ts7OjDGwKRwAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgVaGJ2yWvWXu6ZejDpS5ul9eMNvL1H8vVL9U5h/75QV1e5l7++VCO8u83C8BLi41ANaXzP4yF9qOMmN/FpM5v1Dm/0MNgLE/z+zUv6uwKRwBAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBfA4Am+2d+DkA9dWq4/1yoU+V+Y9+yUXuL8ts7Zej7ijz+X55QfkcAKBpF+vnANxWhjbUb6Bj/403xucAEMkRAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAkGjr8IRqy/CEKAKARGvDE6qdwxOiCAASrQ5PqL5neEIUAUAiAcAsAUAkAUAiRwBZXh+eiwgAIgkAEtkByHJ8eC4iAIgkAEg0FQAvlfl2v6QB9b/nMgKASAKARFMBcKjMM/2SBhwbnosIACIJABJN3QE4Mjxpgx0AGCEASDS1A/Di8KQNAgBGCAASTQWAHYC2CAAYIQBI5AggizsAMEIAkMgRQBY7ADBCAJDIEUAWAQAjBACJHAFkEQAwQgCQyBFAFncAYIQAIJEjgCx2AGCEACCRI4AsAgBGCAASXTY8FxEAbZkKgC1ltvVLyCEASFN/2qv/D38ZdwDaMnUHoLILQBwBQJqp8//KDkBbpnYAKgFAHAFAmqnz/0oAtEUAwAgBQJqz2QFwBNAWAQAjBABpHAHkcQcARggA0kwdAayXOdovaYQdABghAEgztQNQf1qsEUA7BACMEACkmQoA5//tEQAwQgCQxqcA5nEHAEYIANJM7QAIgPYcH57LCADiCADSOALIU+90TEWAACCOACCNI4BMU/cABABxBABpRncAdu3a1f30bbd1v/qJTwiANk3dAxAAxBEApDkjAH5sz57uYx//eHfVle/tvvbVxwVAm+wAwBwBQJrTAuDnP/KR7gMfuLW7/76Hu6985YHusccecAegTQIA5ggA0rxxB+AX77yz27ljd/fl+7/RPf74N7rnnnuiO378RTsAbRIAMEcAkObUDsCHP/xz3SUrO7sHH3yke/bZR7ojR54/9Q8LAdCmqTsAO4cnxBAApFm95ZZbumuufW/39a8/UX7qf7x75ZXTfjh0BNAmOwAwRwAQZcuWLWsf/NCHukcf+XZ38OBT5Zv/GT8Y2gFokwCAOQKAJNt/5NZbt75w6Fi3b98z3Xe/e3D48mkEQJsEAMwRACRZvemHbuqefnp/d/jw/uFLZxAAbfI5ADBHABDj8iuuWLv8it3dgQPPd0ePHhq+egZ3ANpkBwDmCABiXHP11asvvHCkvuo3fGWUHYA2CQCYIwCIccUVu1ePHn2pe/XVpb8XRgC0SQDAHAFAjO07tq++9tqJ7vXXTwxfGSUA2nQ2nwOw0i8hgwAgxvrJk2srKytdnQXq1sDSOuCiNbUDUP9S7OiXkEEAEOPYsZdWd+zY1l166bbhK2fw03+7pgKgcgxAFAFAjEOHnl9dW9vVbd++a/jKGQRAuwQAzBEAxNi3b9/au999eXfZZZcv2gXwCmC7pu4AVAKAKAKAGCdOnFj91hPf6r7v+6/q1tauGr56GjsA7bIDAHMEAElWH/7mw93111/b7d59TXfJJVuGL79BALRLAMAcAUCStaeefLI7fPg73Q03XNddeeV1w5ff4AigXQIA5ggAkqzW/3Pfl+7rbv7h93U/cN37ut27rz31DwZ2ANrlDgDMEQAkORUABw7s7774hXu7PXve31133fu7d73rPaf+YSEA2mUHAOYIAJKsDc/uoYce6v7twa92P/XBm7sfvPHm7pprbui2bt0uANpVP+RpvV8uJACIIgBIcmoHYMMDDzzQfemf/6n7yZ+4qduz59bu+ut/1B2AdtVv/i/3y4UEAFEEAElOC4Dq0Ucf7e6++7PdyfVj3c/87I/bAWjb1D0AAQBwHu0tU3/6WjT7y1wo9Rx47M9waq666nvvLE/a9d9lRv/bD/NrZS6k28uM/Tlmx+8nYNPYASDFpWXqb3xb6ODBA44A2jZ1EdAOAFEEACnO2P4f4QigbQIAZggAUggA3AGAGQKAFG+8AriEAGibHQCYIQBIcTY7AO4AtE0AwAwBQApHAAgAmCEASDF1BPBamVf6JY1yBwBmCABSTO0A2P5vnx0AmCEASDEVALb/2ycAYIYAIMXUEYAAaJ8AgBkCgBR2AHAHAGYIAFK4A4AdAJghAEhhB4CpANhWZku/hPYJAFK4A8BUAFR2AYghAEjhCICpOwCVACCGACCFIwDsAMAMAUAKRwAIAJghAEhhBwABADMEACncAcAdAJghAEhQ/57v6pcL2QFonx0AmCEASHBZmZV+uZAAaJ8AgBkCgART2/+VI4D2HS+z3i8X2jk8oXkCgARnEwB2ANpXv/nXCFjGDgAxBAAJpl4BrARAhqljAAFADAFAAjsAbBAAMBAAJJgKgJNlzuYVMS5+AgAGAoAEPgWQDVOhJwCIIQBIMLUDIABy2AGAgQAgwVQAeAUwhwCAgQAggSMANggAGAgAEjgCYIM7ADAQACQQAGywAwADAUCCqSMAdwByCAAYCAAS2AFggwCAgQAggQBggzsAMBAAJPAaIBvsAMBAAJDAa4BsEAAwEAAkcATABgEAAwFAAkcAbJi6A7ClzLZ+CW0TALRuV5mpv+d2AHJM7QBUdgGIIABo3dRP/5UAyCEAYCAAaJ0AYJYAgIEAoHVTbwBU7gDkmLoDUAkAIggAWmcHgFl2AGAgAGjdVACslznaLwkgAGAgAGjd1BFA3RI+2S8JIABgIABo3dQOgO3/LMfL1F2fZQQAEQQArRMAzKrf/GsELCMAiCAAaJ0AYN7UMYAAIIIAoHVTdwC8AphHAEAhAGidHQDmTX0WgAAgggCgdQKAeXYAoBAAtM4RAPMEABQCgNbZAWCeAIBCANA6AcA8dwCgEAC0buoIQADksQMAhQCgdVM7AO4A5BEAUAgAWucIgHkCAAoBQMt2lNnaLxcSAHncAYBCANCyqZ/+K0cAeewAQCEAaNnZBIAdgDwCAAoBQMsEAGMEABQCgJZNvQJYCYA87gBAIQBomTsAjJnaAaiXR1f6JbRLANCyqQB4ucyJfkmQqQCo3/xrBEDTBAAt8ymAjJkKgMoxAM0TALRsagfA9n+mqTsAlQCgeQKAlk0FgB2ATHYAoBAAtMwRAGMEABQCgJbZAWCMAIBCANAydwAY4w4AFAKAltkBYEx9/XO9Xy4kAGieAKBl7gAwpn7zP94vFxIANE8A0DJHACwydQ9AANA8AUDLHAGwiN8HQDwBQMscAbCIHQDiCQBaZgeARQQA8QQArbq0zNQvdHEHIJcAIJ4AoFVT2/+VHYBc7gAQTwDQqqnt/0oA5LIDQDwBQKvOJgAcAeQSAMQTALTKEQDLCADiCQBa5QiAZdwBIJ4AoFVTAfBamfqZ8GSyA0A8AUCrfAYAywgA4gkAWuVTAFlGABBPANAqOwAs4w4A8QQArZoKAK8AZrMDQDwBQKscAbCMACCeAKBVjgBYZioAtpXZ0i+hTQKAVgkAlpm6A1DZBaBpAoBWTR0BuAOQbWoHoBIANE0A0Co7ACwjAIgnAGiVAGAZAUA8AUCrHAGwjDsAxBMAtMoOAMvYASCeAKBF9e/1rn65kADIdrzMer9cSADQNAFAiy4bnssIAGoELCMAaNrK8ITNsrfMPf1y1IEyV/fL8+Y9Zfb1y4V+pcx/9ktCfaHM5f1y1C+X+Vy/3BS3l7m3Xy60s4xfWw1clGoA1K3WRbO/zPm2vczrZcb+fcac7dxWZjPVABj7987OjjKwKRwB0KJXykztAMCUx4YnNEkA0Kr/Gp7wVnxnGGiWAKBVAoC349HhCc0SALTqyeEJb4Xtf5onAGiVHQDeDgFA8wQArbIDwNshAGieAKBVT5U52S/hnLkDQPMEAK2qrwL+a7+Ec/KVMof7JbRLANCyPxiecC4+NTyhaQKAlv1dGR8IxLl4sMwX+yW0TQDQshNl/rhfwlnx0z8xBACt+2wZv0yFs/HvZf6hX0L7BACte77M3/RLWOrXhydEEAAkcBmQKfW1v3pnBGIIABI8VOZf+iWMqj/911+/CzEEACnsArDI42X+tl9CDgFAis+XebZfwml+o4xPjSSOACBFfSXwM/0S3lB/Z4RLokQSACTxSiDzfrPM6/0SsggAktRXAv+6X0L3dJm/6peQRwCQ5g+HJ9xVph4NQSQBQJr6SuCX+yXB6u+I+It+CZkEAInsAvDpMq/2S8gkAEhUP/HNK4G5/qfM3f0ScgkAEtVb335LYK7fLuNtEOIJAFJ5JTDTwTJ/2i8hmwAg1aEyn+uXBPndMi/1S8gmAEjmMmCWGn2OfmAgAEj2cBmvBOb4vTJH+yUgAEjntwRm+N8ydnxghgAgXf0tgc/0Sxr2+2Ve7JdAJQBI55XA9tVv/DUAgBkCAPoPhTneL2nQH5U53C+BDQIA+tvhfktgm46VqZf/gDkCAHouA7bpM2Xqr4EG5ggA6H2zzP39kkbUY53f6ZfAPAEAb7IL0JY/K3OgXwLzBAC86e/LeCWwDa+U+a1+CYwRAPAmrwS248/LPNcvgTECAE5Xf0ugVwIvbq+V+XS/BBZZGZ6wWfaWuadfjqpntFf3y3eMPylT/9xcnOrft4/1y3e028vc2y8X2lnGr60GLkr1G+n6ktlfBhLVABj738Ts7CgDm8IRAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEEgAAECgleEJm2VvmXv65agjZT7ZLyHKjWU+2i8X2lnm5X4J55cAYLNNBQCwmABg0zgCAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACeQ2QzXZHmbv6JXCObi7zar8EAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAB4K7ru/wD7/wfplmjKCQAAAABJRU5ErkJggg=='
        : 'data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAgAAAAIACAYAAAD0eNT6AAAAAXNSR0IArs4c6QAAAARnQU1BAACxjwv8YQUAAAAJcEhZcwAADsMAAA7DAcdvqGQAABCBSURBVHhe7d1Jr1xHGcfhXMjgGxJECBCBACEGiUkMGxYgQKxwBBIgxAIikC3GIAYhJoVhw5dA2SAvYJ1tPgcrvgBStkCCg41j3kqdSzqdPrc6jtvxrf/zSK9O7WIJ4/u7VXW67wAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAIMbR8oRDuLvmr30JvEyP1TzRl3DzCQAO6VzN5b4EXqaLNZf6Em6+1yxPACCIAACAQAIAAAIJAAAIJAAAIJAAAIBAXgPkkPZ5DfDxmr/1JUT5Q839fbmT1wCBM6sFwPXBnK+BRE/V7Pr/xMlcqIGDcQQAAIEEAAAEEgAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCABAACBBAAABBIAABBIAABAIAEAAIEEAAAEEgAAEOhoecIhnKu53JerHq55si9va3+sudiXnEGXan7Ql7eNp2oe6sud2t+39ucGOHNaAFwfzPma2907a67U7Przm7Mx/655Y83tpAXArj/ryVyogYNxBABjv665qy85o45rvtuXQCMA4HRvq/l2X3LG/bDmtX0JCAA43a9q7ulLzrh2lPOlvgQEAKxrF7S+15dM4ifLE+IJAFj3i5p2dsw8Plvzkb6EbAIAdntTzaN9yWTsAkARALDbz2pe15dM5hs1D/Yl5BIA8FIP1PyoL5lQO9b5Tl9CLgEAL/XTmtf3JZPySiDxBAC8WPvB3wKAubVXAr/cl5BJAMCL/bjmDX3J5FwGJJoAgBfcV9Mu/5HhMzUf7UvIIwDgBe1c2O3wLG3HByIJAOjurfl5XxLkkRrRRyQBAN33a97SlwRpX1ntWwKJJACg/xD4ZV8SyCuBRBIA0D8U5q19SaB31HylLyGHACDd3TW/7kuCuQxIHAFAugs1b+9LgrVXAj/Wl5BBAJDszprH+hLsApBFAJDsmzXv6kt4/lsC29dAQwQBQKp26/s3fQnP80ogUQQAqb5e896+hP97tKYdDcH0BACJ2t/73/YlvEh7JdC3BBJBAJDoazXv70t4Cd8SSAQBQJqjmt/1Jez06RqvBDI9AUCa9olvH+5LWGUXgOkJANL47Z99tEuiXglkagKAJF+s+Xhfwqm8Esj0BABJfr88YR/tWwK9Esi0BAApPl/zib6EvbTviPAtgUxLAJDCb//cCJcBmZYAIMEDNZ/qS3hZPllzT1/CXAQACbz2x41q/0a+py9hLgKABB9annAjfGcEUxIAJBAAvBLvW54wFQFAAgHAK2EHgCkJABK4A8ArYQeAKQkAZvfmZeBGCQCmJACYne1/Xqn2gUBeBWQ67atR4VDa56lf7stVD9c82ZcH8UjNn/typ3/UnO9LQn2g5k99uapFwN/78qZ5quahvtzpYs2lvgQ4W1oAXB/MoX/4frVm13/3ZJ6pIdvnanb93dic19fcbC0Adv23TuZCDRyMIwBm9+/lueZ4eZLr/uV5mqeXJ0xDADC7UQC0YzARkG0UAG2X6Lm+hHkIAGY3CoDm3uVJplEA/Gt5wlQEALPbJwBetzzJNDrf/+fyhKkIAGZnB4AROwBEEgDMTgAwIgCIJACYnQBgxBEAkQQAs3MHgBE7AEQSAMzuWs2VvlxlByCbACCSACDBaBdAAGQbBYAjAKYkAEggADjN6A6AHQCmJABIMAoAdwCyOQIgkgAggR0ATuMIgEgCgAQCgNPYASCSACCBAGBN+8rqu/pylQBgSgKABO4AsGb0238jAJiSACCBHQDW7BMA7gAwJQFAAgHAmtErgI0dAKYkAEggAFjjCIBYAoAE7gCwxhEAsQQACewAsGZ0BPBszX/7EuYiAEggAFjjMwCIJQBIIABYMwoA2/9MSwCQwB0A1tgBIJYAIIEdANb4JkBiCQASjALguOaoLwnjCIBYAoAEowBoP/zbZ8KTxxEAsQQACUYB0LgHkMkRALEEAAn2CQD3ADLZASCWACCBAGCNOwDEEgAkEACssQNALAFAAncAWOMOALEEAAnsALDGEQCxBAAJ2he6XO/LVQIgz501o9c/7QAwLQFAgvbDv0XAaQRAntH2fyMAmJYAIMXoGMAdgDyj7f/GEQDTEgCkGAWAHYA8+wSAHQCmJQBIIQDYJgCIJgBIIQDY5g4A0QQAKdwBYNtoB+BqzejyKJxZAoAUdgDYNgoAv/0zNQFACgHANp8CSDQBQAoBwLbRDoBXAJmaACCFOwBscwRANAFACjsAbBMARBMApBAAbBvdAXAEwNQEACkEANvsABBNAJDCHQC2CQCiCQBS2AFgmyMAogkAUggAttkBIJoAIMUoAI5rjvqSEAKAaAKAFKMAaD/8WwSQQwAQTQCQYhQAjWOAHO3fvtHFT3cAmJoAIIUAYNN9NaMjHzsATE0AkEIAsGm0/d8IAKYmAEixTwD4LIAco1cAG0cATE0AkMIOAJvsABBPAJBCALBJABBPAJBCALBpFADP1TzTlzAnAUCKKzXX+nKVOwA5RncA/PbP9AQASUa7AHYAcvgQIOIJAJIIAE6MAsAbAExPAJBEAHDCEQDxBABJRgHgDkAORwDEEwAksQPACQFAPAFAEgHAidERgDsATE8AkEQAcMIOAPEEAEncAeCEACCeACCJHQBOeA2QeAKAJAKAE14DJJ4AIIkA4IQjAOIJAJK4A8AJRwDEEwAksQNA00Jv9G+fHQCmJwBIIgBoRr/9NwKA6QkAkggAmn0CwBEA0xMAJBkFwHHNUV8yMTsAUAQASS4vzzXth3+LAOY2egWwEQBMTwCQZLQD0DgGmN9oB+B6zdN9CfMSACQRADSjAHim5rm+hHkJAJLsEwA+C2B+PgUQigAgiR0AmtEOgAAgggAgiQCgGQWAVwCJIABIIgBo7ABAEQAkcQeAxh0AKAKAJHYAaBwBQBEAJLlWc6UvVwmA+TkCgCIASDPaBRAA83MEAEUAkGYUAO4AzM8OABQBQBo7ALgDAEUAkEYAYAcAigAgjQDAHQAoAoA07gBku6fmrr5c5QiACAKANHYAso22/xs7AEQQAKQRANlG2/+NACCCACCNAMi2zw6AIwAiCADSuAOQzREALAQAaewAZBMAsBAApBEA2UZ3AC7X/LcvYW4CgDQCIJsPAYKFACCNOwDZBAAsBABpRgFwruaoL5mQTwGEhQAgzSgA2g//475kQqMdAK8AEkMAkGYUAI17APNyBAALAUCafQLAPYB5CQBYCADS2AHINroD4AiAGAKANAIgmx0AWAgA0giAbAIAFgKANO4AZHMEAAsBQBo7ANnsAMBCAJBGAGQTALAQAKR5tuZ6X64SAHO6s2b0IU+OAIghAEjTfvi3b3w7jTsAcxr99t/YASCGACDR6BjADsCcBABsEAAkEgCZBABsEAAkEgCZRq8ANu4AEEMAkGgUAO4AzMkOAGwQACSyA5BpFABXa/7TlzA/AUAiAZBpFAC2/4kiAEgkADKN7gDY/ieKACCRzwHINNoBEABEEQAksgOQyREAbBAAJBIAmRwBwAYBQCIBkMkRAGwQACQaBYA7AHMSALBBAJDIDkAmdwBggwAg0SgA2lfGHvUlE3EHADYIABKNAqAZfW88Z48jANggAEi0TwC4BzAfRwCwQQCQaJ8AcA9gPo4AYIMAIJEAyNPudIx2dQQAUQQAiQRAnvtqRhc7HQEQRQCQyB2APKPz/8YOAFEEAInsAOQZnf83AoAoAoBEAiDPPjsAjgCIIgBIJADyOAKALQKARO4A5BkdAVyr2efvBUxDAJDoSk37B/80dgDmMtoBeHp5QgwBQKrRb3sCYC4+BRC2CABSCYAsowBw/k8cAUCqUQC4AzAXHwMMWwQAqewAZHEEAFsEAKkEQBZHALBFAJBKAGRxBABbBACp3AHI4ggAtggAUtkByOIIALYIAFIJgCyOAGCLACCVAMjiCAC2CABSuQOQ4501D/blKjsAxBEApLIDkOPdNaP/PQUAcQQAqUYBcLw8ySAAiCMASDUKgNcuTzK4A0AcAUCqUQCQxQ4AcQQAqQQAmwQAcQQAqS4vT2gcARBHAJDq2vKE5uryhBgCAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACHS0POEQztVc7stVD9c82Ze31JdrnujLna7WfKsvOeM+WPP7vlx1XPNsX94yT9U81Jc7Xay51JcAZ0sLgOuDOV/zamgBsOvPYzKn/V291VoA7PqznMyFGjgYRwAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCCfA8Ah3c6fA/CFmr/0JTz/Pv5/+vKW8TkAwLRu588BgFebzwHgVeUIAAACCQAACCQAACCQAACAQAIAAAIJAAAIJAAAIJAAAIBAAgAAAgkAAAgkAAAgkAAAgEACAAACCQAACCQAACDQ0fKEQzhXc7kvVz1e87e+hCh/qLm/L3e6WHOpL+HmEwAc0j4BAOwmADgoRwAAEEgAAEAgAQAAgQQAAAQSAAAQSAAAQCCvAXJId9f8tS+Bl+mxmif6EgAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA4Ebdccf/AG197TJmn1x2AAAAAElFTkSuQmCC'"
        class="h-64 cursor-pointer"
        x-on:click="clicou++; on = !on; on === true ? button_1_on() : button_1_off()"
        src=""
      />
      <p
        class="text-center text-xl font-black"
        x-html="!clicou ?'Clica logo em mim! ╰（‵□′）╯'
      : clicou === 1 ? 'Desliga logo!</br> Tá gastando energia! ╰（‵□′）╯'
      : clicou > 1 && clicou < 15 ? `Você clicou ${clicou} vezes ☜(ﾟヮﾟ☜)`
      : 'Vai queimar a lâmpada assim!<br/> ╰（‵□′）╯'"
      ></p>
    </section>
  </body>
  
</html>



)=====";


void paginaInicial()
{
  server.send(200, "text/html", PaginaHTML); //Envia a pagina
}

void webSocketEvent(uint8_t num, WStype_t type, uint8_t * payload, size_t length) {

  switch (type) {
    case WStype_DISCONNECTED:
      Serial.printf("[%u] Disconectado!\n", num);
      break;
    case WStype_CONNECTED:
      {
        IPAddress ip = webSocket.remoteIP(num);
        Serial.printf("[%u] conectado de %d.%d.%d.%d url: %s\n", num, ip[0], ip[1], ip[2], ip[3], payload);
        webSocket.sendTXT(num, "Connected");
      }
      break;
    case WStype_TEXT:
      {

        Serial.printf("[%u] get Text: %s\n", num, payload);
      String state = String((char*)( payload));
      Serial.println(state);

      if(state == "OFF"){
        digitalWrite(D1,LOW);
      }

      if(state == "ON"){
        digitalWrite(D1,HIGH);
      }
        
        break;
      }
  }
}

void setup() {
  pinMode(D1, OUTPUT);
  digitalWrite(D1, LOW);
  Serial.begin (115200);

  // IP Configuraçoes
  if (!WiFi.config(local_IP, gateway, subnet)) {
  Serial.println("falha ao configurar");}
  WiFi.begin (ssid, password);//conecta ao wifi

    //return;

  while (WiFi.status() != WL_CONNECTED) { //espera a conexão
    delay(500);

    Serial.print(".");
  }
  if(WiFi.status() == WL_CONNECTED){
  Serial.println("");
  Serial.println("WiFi conectado");
  Serial.println("Endereço de IP: ");
  Serial.println(WiFi.localIP());}

  server.on("/",paginaInicial); 
  server.begin(); 
  webSocket.begin();
  webSocket.onEvent(webSocketEvent);
}

void loop() {
  server.handleClient();
  webSocket.loop();

  
 
  
}
